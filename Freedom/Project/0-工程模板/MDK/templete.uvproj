# Keil uVision project templete.uvproj, settings and files
target mk60d10_flash (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\Libraries\startup\CoreSupport;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\drivers\K\inc;..\..\..\Libraries\utilities\inc;..\..\..\Libraries\devices\inc;..\src;..\..\..\Libraries\znfat;..\..\..\Libraries\emWin\Include;..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\Libraries\utilities\fatfs;..\..\..\Libraries\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c
  group drivers
    ../../../Libraries/drivers/K/src/: common.c dac.c ftm.c gpio.c lptmr.c pit.c systick.c uart.c wdog.c dma.c
  group devices
    ../../../Libraries/devices/src/: OLED.c SCCB.c ov7725.c ov7725_reg.c
  group app
    ../../../Libraries/app/inc/: app_include.h
    ../../../Libraries/app/src/: Image.c SystemInit.c Control.c key.c Beeper.c fuzzy.c UartLink.c PID.c CusTomPID.c TargetSpeed.c
    ../../../../: readme.txt
